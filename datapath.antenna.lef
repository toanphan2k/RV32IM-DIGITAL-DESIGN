

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO datapath 
  PIN clk 
    ANTENNAPARTIALMETALAREA 0.0182 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0504 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.7382 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.8192 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 14.4222 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 65.0124 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.73935 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 196.914 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 893.95 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.24691 LAYER Via5 ;
  END clk
  PIN rst_n 
    ANTENNAPARTIALMETALAREA 2.1212 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.5454 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.6278 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.754 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.6397 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 48.7789 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 220.744 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.73302 LAYER Via4 ;
  END rst_n
  PIN c_pc_f[31] 
    ANTENNAPARTIALMETALAREA 6.5364 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 29.4138 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.9612 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.2912 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 3.5288 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 15.9084 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.39645 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 47.9005 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 221.681 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.45676 LAYER Via5 ;
  END c_pc_f[31]
  PIN c_pc_f[30] 
    ANTENNAPARTIALMETALAREA 1.4484 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.5178 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.73 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.2508 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 8.5208 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 38.3724 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 49.2243 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 232.183 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.47133 LAYER Via5 ;
  END c_pc_f[30]
  PIN c_pc_f[29] 
    ANTENNAPARTIALMETALAREA 1.4972 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.7374 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.5772 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.5632 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 8.6648 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 39.0204 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 57.9103 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 265.369 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.45964 LAYER Via5 ;
  END c_pc_f[29]
  PIN c_pc_f[28] 
    ANTENNAPARTIALMETALAREA 1.4956 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.7302 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.8164 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.1396 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 8.9006 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 40.05 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 47.6794 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 232.684 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.52774 LAYER Via5 ;
  END c_pc_f[28]
  PIN c_pc_f[27] 
    ANTENNAPARTIALMETALAREA 1.5292 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.8814 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.5244 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.8256 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 8.5992 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 38.7252 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 58.5765 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 267.608 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.44057 LAYER Via5 ;
  END c_pc_f[27]
  PIN c_pc_f[26] 
    ANTENNAPARTIALMETALAREA 1.4172 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.3774 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.1708 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.2344 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.0096 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 40.6008 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 313.339 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1409.88 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.44217 LAYER Via5 ;
  END c_pc_f[26]
  PIN c_pc_f[25] 
    ANTENNAPARTIALMETALAREA 4.1684 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.7578 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2596 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.134 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 6.4938 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 29.2194 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 7.9084 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 35.5536 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 35.4789 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 165.455 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.48795 LAYER Via6 ;
  END c_pc_f[25]
  PIN c_pc_f[24] 
    ANTENNAPARTIALMETALAREA 4.1364 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.6138 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.8676 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.87 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 6.776 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 30.5208 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 429.926 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1942.5 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 4.47531 LAYER Via5 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 7.1332 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 32.0652 LAYER Metal6 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 448.531 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 2026.13 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.47873 LAYER Via6 ;
  END c_pc_f[24]
  PIN c_pc_f[23] 
    ANTENNAPARTIALMETALAREA 5.5412 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.9354 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2596 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.134 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 5.2762 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 23.7402 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 7.9286 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 35.676 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 34.1612 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 161.552 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.4851 LAYER Via6 ;
  END c_pc_f[23]
  PIN c_pc_f[22] 
    ANTENNAPARTIALMETALAREA 5.5108 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.7986 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0924 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3816 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 5.4504 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 24.5556 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 8.1226 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 36.486 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 61.3585 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 279.368 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.46838 LAYER Via6 ;
  END c_pc_f[22]
  PIN c_pc_f[21] 
    ANTENNAPARTIALMETALAREA 5.4804 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.6618 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2596 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.134 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 5.752 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 25.9128 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 369.407 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1665.76 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 5.46914 LAYER Via5 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 7.3428 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 33.0084 LAYER Metal6 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 388.559 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1751.85 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.46838 LAYER Via6 ;
  END c_pc_f[21]
  PIN c_pc_f[20] 
    ANTENNAPARTIALMETALAREA 5.526 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.867 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.5332 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3652 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 5.7336 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 25.83 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 374.407 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1690.72 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 4.47531 LAYER Via5 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 6.2606 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 28.17 LAYER Metal6 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 390.737 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1764.2 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.46838 LAYER Via6 ;
  END c_pc_f[20]
  PIN c_pc_f[19] 
    ANTENNAPARTIALMETALAREA 2.8356 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.7602 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.3052 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3392 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.8008 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 35.1324 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.0382 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1692 LAYER Metal6 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via6 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal7 ; 
    ANTENNAPARTIALMETALAREA 0.4648 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1204 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 47.3636 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 216.623 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 6.55539 LAYER Via7 ;
  END c_pc_f[19]
  PIN c_pc_f[18] 
    ANTENNAPARTIALMETALAREA 1.7692 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.9614 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1076 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.45 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 8.7608 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 39.4524 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.0382 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1692 LAYER Metal6 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via6 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal7 ; 
    ANTENNAPARTIALMETALAREA 0.4648 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1204 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 56.1523 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 256.172 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 6.60249 LAYER Via7 ;
  END c_pc_f[18]
  PIN c_pc_f[17] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.29 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2708 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 10.612 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 47.7828 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.0564 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal6 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via6 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal7 ; 
    ANTENNAPARTIALMETALAREA 0.4536 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.07 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 50.3516 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 228.207 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 6.59793 LAYER Via7 ;
  END c_pc_f[17]
  PIN c_pc_f[16] 
    ANTENNAPARTIALMETALAREA 0.1052 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4734 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1684 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7236 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 10.66 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 47.9988 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.0382 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1692 LAYER Metal6 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via6 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal7 ; 
    ANTENNAPARTIALMETALAREA 0.4424 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0196 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 37.0965 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 174.575 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 6.51313 LAYER Via7 ;
  END c_pc_f[16]
  PIN c_pc_f[15] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1076 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.45 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 10.2504 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 46.1556 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.0564 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal6 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via6 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal7 ; 
    ANTENNAPARTIALMETALAREA 0.4606 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.07 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.39645 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 38.4475 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 174.803 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 6.51115 LAYER Via7 ;
  END c_pc_f[15]
  PIN c_pc_f[14] 
    ANTENNAPARTIALMETALAREA 0.0572 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2574 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1532 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6552 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.3064 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 41.9076 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.39645 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 161.093 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 730.873 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.51216 LAYER Via5 ;
  END c_pc_f[14]
  PIN c_pc_f[13] 
    ANTENNAPARTIALMETALAREA 1.7692 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.9614 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.062 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2448 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 8.8126 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 39.654 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3672 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 40.9669 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 202.637 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.46088 LAYER Via5 ;
  END c_pc_f[13]
  PIN c_pc_f[12] 
    ANTENNAPARTIALMETALAREA 0.1852 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8334 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1076 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.45 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 10.2984 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 46.3716 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.27855 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 55.7915 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 272.557 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.44962 LAYER Via5 ;
  END c_pc_f[12]
  PIN c_pc_f[11] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1836 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.792 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.3524 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 10.3304 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 46.5156 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1917 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 63.2005 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 305.423 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.56619 LAYER Via5 ;
  END c_pc_f[11]
  PIN c_pc_f[10] 
    ANTENNAPARTIALMETALAREA 0.0572 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2574 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1532 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6552 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.7056 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 43.704 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.39645 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 38.3798 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 190.983 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.50982 LAYER Via5 ;
  END c_pc_f[10]
  PIN c_pc_f[9] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.138 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5868 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.3524 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.2904 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 41.8356 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1917 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 63.4514 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 306.385 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.57489 LAYER Via5 ;
  END c_pc_f[9]
  PIN c_pc_f[8] 
    ANTENNAPARTIALMETALAREA 0.2332 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0494 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0924 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3816 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.0816 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 40.896 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.27855 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 65.9945 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 300.861 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.4866 LAYER Via5 ;
  END c_pc_f[8]
  PIN c_pc_f[7] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1076 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.45 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.4152 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 42.3972 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.39645 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 36.4814 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 182.447 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.48313 LAYER Via5 ;
  END c_pc_f[7]
  PIN c_pc_f[6] 
    ANTENNAPARTIALMETALAREA 0.0412 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1854 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1684 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7236 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 10.6984 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 48.1716 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.27855 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 51.3755 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 252.665 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.43357 LAYER Via5 ;
  END c_pc_f[6]
  PIN c_pc_f[5] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1076 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.45 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 10.8896 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 49.032 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.27855 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 56.2118 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 256.673 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.47759 LAYER Via5 ;
  END c_pc_f[5]
  PIN c_pc_f[4] 
    ANTENNAPARTIALMETALAREA 0.5372 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4174 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0772 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3132 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.3064 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 41.9076 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.27855 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 63.6066 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 290.282 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.40713 LAYER Via5 ;
  END c_pc_f[4]
  PIN c_pc_f[3] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1228 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5184 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.5784 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 43.1316 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.27855 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 55.4609 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 256.037 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.57015 LAYER Via5 ;
  END c_pc_f[3]
  PIN c_pc_f[2] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2292 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9972 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.7384 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 43.8516 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.27855 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 65.5999 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 300.106 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.41163 LAYER Via5 ;
  END c_pc_f[2]
  PIN c_pc_f[1] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2596 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.134 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.1944 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 41.4036 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.27855 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 52.1425 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 237.232 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.48387 LAYER Via5 ;
  END c_pc_f[1]
  PIN c_pc_f[0] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1836 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.792 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.2118 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 41.4504 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.27855 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 46.8389 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 224.154 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.45582 LAYER Via5 ;
  END c_pc_f[0]
  PIN f_inst[31] 
    ANTENNAPARTIALMETALAREA 1.0812 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8654 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.062 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2448 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 8.2206 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 36.99 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.12015 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 114.89 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 526.626 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.18033 LAYER Via5 ;
  END f_inst[31]
  PIN f_inst[30] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1988 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8604 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 9.6568 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 43.4844 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1656 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 129.996 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 593.482 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 4.62708 LAYER Via5 ;
  END f_inst[30]
  PIN f_inst[29] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1228 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5184 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 9.3878 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 42.2424 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.07785 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 188.771 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 858.856 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.3049 LAYER Via5 ;
  END f_inst[29]
  PIN f_inst[28] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1988 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8604 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 9.448 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 42.5448 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.07785 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 216.252 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 982.51 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 4.74559 LAYER Via5 ;
  END f_inst[28]
  PIN f_inst[27] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1076 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.45 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 9.448 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 42.5448 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.07785 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 230.147 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1040.05 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 9.34193 LAYER Via5 ;
  END f_inst[27]
  PIN f_inst[26] 
    ANTENNAPARTIALMETALAREA 0.7772 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4974 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0382 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1692 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 8.6936 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 39.15 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0648 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 242.889 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1098.43 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.07099 LAYER Via5 ;
  END f_inst[26]
  PIN f_inst[25] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0924 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3816 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 9.2264 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 41.5476 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.25335 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 93.7018 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 429.428 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 4.41522 LAYER Via5 ;
  END f_inst[25]
  PIN f_inst[24] 
    ANTENNAPARTIALMETALAREA 1.0812 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8654 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.354 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.0588 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 8.6982 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 39.1968 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 382.833 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1732.19 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 7.08025 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.4512 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0592 LAYER Metal6 ;
    ANTENNAGATEAREA 0.37035 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 384.052 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1737.75 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 7.08025 LAYER Via6 ;
  END f_inst[24]
  PIN f_inst[23] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.138 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5868 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 14.215 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 64.0512 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3735 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 167.097 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 760.726 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 8.65488 LAYER Via5 ;
  END f_inst[23]
  PIN f_inst[22] 
    ANTENNAPARTIALMETALAREA 0.0412 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1854 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.9636 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.802 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 8.4504 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 38.0556 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.0546 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 0.198 LAYER Metal6 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via6 ;
    ANTENNAPARTIALMETALAREA 0.2344 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0836 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.44505 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 135.829 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 619.406 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 6.40474 LAYER Via7 ;
  END f_inst[22]
  PIN f_inst[21] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.6412 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8512 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 11.2072 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 50.5188 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3249 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 124.028 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 565.382 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.3059 LAYER Via5 ;
  END f_inst[21]
  PIN f_inst[20] 
    ANTENNAPARTIALMETALAREA 2.9346 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.1742 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.5344 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.4336 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 9.7904 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 44.0172 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.27945 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 182.17 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 823.175 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 5.20791 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 1.2598 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6664 LAYER Metal6 ;
    ANTENNAGATEAREA 0.39645 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 185.347 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 837.468 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 5.20791 LAYER Via6 ;
  END f_inst[20]
  PIN f_inst[19] 
    ANTENNAPARTIALMETALAREA 1.0004 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5018 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.2876 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.76 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 14.3158 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 64.476 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.41895 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 109.141 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 493.017 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.92989 LAYER Via5 ;
  END f_inst[19]
  PIN f_inst[18] 
    ANTENNAPARTIALMETALAREA 0.0412 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1854 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.1868 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.3064 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 10.5176 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 47.358 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 10.4162 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 46.8072 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 91.7667 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 421.047 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 5.77778 LAYER Via6 ;
  END f_inst[18]
  PIN f_inst[17] 
    ANTENNAPARTIALMETALAREA 1.1602 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1894 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.6702 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5132 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 12.1328 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 54.7128 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.37035 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 99.0122 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 448.526 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.17284 LAYER Via5 ;
  END f_inst[17]
  PIN f_inst[16] 
    ANTENNAPARTIALMETALAREA 1.1452 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1534 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.81 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.1108 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 13.5522 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 61.0344 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.27945 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 408.427 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1839.24 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 5.20791 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.515 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3148 LAYER Metal6 ;
    ANTENNAGATEAREA 0.3087 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 410.095 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1846.74 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 5.20791 LAYER Via6 ;
  END f_inst[16]
  PIN f_inst[15] 
    ANTENNAPARTIALMETALAREA 0.0252 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1134 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.7584 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.3444 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 15.3654 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 69.1992 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.33795 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 67.8924 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 312.169 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.17284 LAYER Via5 ;
  END f_inst[15]
  PIN f_inst[14] 
    ANTENNAPARTIALMETALAREA 0.0572 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2574 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.4914 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.6744 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.7654 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 34.9704 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.31185 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 274.383 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1241.51 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.88889 LAYER Via5 ;
  END f_inst[14]
  PIN f_inst[13] 
    ANTENNAPARTIALMETALAREA 0.0892 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4014 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.3404 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.9976 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 8.624 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 38.8656 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3411 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 288.517 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1306.29 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.22222 LAYER Via5 ;
  END f_inst[13]
  PIN f_inst[12] 
    ANTENNAPARTIALMETALAREA 0.8892 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0014 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.4748 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.6024 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 8.1918 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 36.918 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2664 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 82.0216 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 375.155 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.22222 LAYER Via5 ;
  END f_inst[12]
  PIN f_inst[11] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.4074 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.2964 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.4686 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 33.606 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 10.953 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 49.1544 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2664 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 72.9806 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 337.347 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.08796 LAYER Via6 ;
  END f_inst[11]
  PIN f_inst[10] 
    ANTENNAPARTIALMETALAREA 1.0796 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8582 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.29 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2708 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 8.635 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 38.9412 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.29565 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 167.761 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 757.666 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.48302 LAYER Via5 ;
  END f_inst[10]
  PIN f_inst[9] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.5788 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5704 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 9.6064 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 43.344 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.29565 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 91.0193 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 410.618 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.5679 LAYER Via5 ;
  END f_inst[9]
  PIN f_inst[8] 
    ANTENNAPARTIALMETALAREA 2.8988 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0446 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 7.806 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 35.0928 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 8.496 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 38.2896 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.25335 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 266.689 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1204.52 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.5679 LAYER Via5 ;
  END f_inst[8]
  PIN f_inst[7] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.6396 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.844 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 11.4528 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 51.624 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.29565 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 240.627 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1086.32 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.37786 LAYER Via5 ;
  END f_inst[7]
  PIN f_inst[6] 
    ANTENNAPARTIALMETALAREA 0.7932 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5694 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 8.15 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.6408 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.8024 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 35.1396 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3087 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 54.6684 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 246.881 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.28395 LAYER Via5 ;
  END f_inst[6]
  PIN f_inst[5] 
    ANTENNAPARTIALMETALAREA 1.1404 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1318 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0382 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1692 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0494 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 8.2366 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 37.062 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.51345 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 54.5722 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 254.274 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 5.30304 LAYER Via6 ;
  END f_inst[5]
  PIN f_inst[4] 
    ANTENNAPARTIALMETALAREA 0.8572 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8574 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.8852 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 26.4492 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0424 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 2.722 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 12.2148 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.37035 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 42.2323 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 194.93 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 5.31041 LAYER Via6 ;
  END f_inst[4]
  PIN f_inst[3] 
    ANTENNAPARTIALMETALAREA 1.0172 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5774 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.6684 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.4736 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.4096 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.872 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 5.458 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 24.5268 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1395 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 120.865 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 547.046 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 5.89741 LAYER Via6 ;
  END f_inst[3]
  PIN f_inst[2] 
    ANTENNAPARTIALMETALAREA 1.3372 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.0174 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0564 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0494 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 8.3886 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 37.746 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.31185 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 146.27 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 665.001 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 5.31538 LAYER Via6 ;
  END f_inst[2]
  PIN f_inst[1] 
    ANTENNAPARTIALMETALAREA 0.9532 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2894 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 9.4132 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 42.3252 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.04545 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 239.215 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1084.59 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.23371 LAYER Via4 ;
  END f_inst[1]
  PIN f_inst[0] 
    ANTENNAPARTIALMETALAREA 0.7292 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2814 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 9.79 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 44.0208 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.04545 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 246.461 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1118.6 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.70285 LAYER Via4 ;
  END f_inst[0]
  PIN store_addr_dmem[31] 
    ANTENNAPARTIALMETALAREA 2.9044 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0698 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.7042 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 30.132 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 469.015 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 2110.83 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 6.34877 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 3.0613 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 13.7304 LAYER Metal5 ;
    ANTENNAGATEAREA 0.4257 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 476.207 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 2143.09 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.46496 LAYER Via5 ;
  END store_addr_dmem[31]
  PIN store_addr_dmem[30] 
    ANTENNAPARTIALMETALAREA 3.1292 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.0814 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 10.5878 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 47.5452 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.43875 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 66.4745 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 300.734 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.43704 LAYER Via4 ;
  END store_addr_dmem[30]
  PIN store_addr_dmem[29] 
    ANTENNAPARTIALMETALAREA 2.6492 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.9214 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.5666 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.484 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 227.929 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1026.63 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 2.39402 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 1.5944 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.2036 LAYER Metal5 ;
    ANTENNAGATEAREA 0.43875 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 231.563 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1043.04 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.43846 LAYER Via5 ;
  END store_addr_dmem[29]
  PIN store_addr_dmem[28] 
    ANTENNAPARTIALMETALAREA 2.3292 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.4814 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.888 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 30.9276 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 244.538 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1099.98 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 3.90171 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 2.0416 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 9.216 LAYER Metal5 ;
    ANTENNAGATEAREA 0.4257 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 249.333 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1121.63 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.44096 LAYER Via5 ;
  END store_addr_dmem[28]
  PIN store_addr_dmem[27] 
    ANTENNAPARTIALMETALAREA 2.5692 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.5614 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.3732 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.6452 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 222.401 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1000.68 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 3.05043 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 1.9944 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 9.0036 LAYER Metal5 ;
    ANTENNAGATEAREA 0.41265 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 227.234 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1022.5 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.4418 LAYER Via5 ;
  END store_addr_dmem[27]
  PIN store_addr_dmem[26] 
    ANTENNAPARTIALMETALAREA 2.1052 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.4734 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.7188 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 30.2004 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 232.968 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1050.38 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 2.39402 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 4.5936 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 20.7288 LAYER Metal5 ;
    ANTENNAGATEAREA 0.4257 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 243.759 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1099.07 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.49031 LAYER Via5 ;
  END store_addr_dmem[26]
  PIN store_addr_dmem[25] 
    ANTENNAPARTIALMETALAREA 1.9924 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.9658 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.4674 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.0376 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 227.953 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1025.66 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 3.05043 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 2.0744 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3636 LAYER Metal5 ;
    ANTENNAGATEAREA 0.41265 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 232.98 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1048.35 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.4418 LAYER Via5 ;
  END store_addr_dmem[25]
  PIN store_addr_dmem[24] 
    ANTENNAPARTIALMETALAREA 2.1692 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.7614 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.5586 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.448 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 243.406 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1095.2 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 3.05043 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 3.58 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 16.1676 LAYER Metal5 ;
    ANTENNAGATEAREA 0.4257 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 251.816 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1133.18 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.44416 LAYER Via5 ;
  END store_addr_dmem[24]
  PIN store_addr_dmem[23] 
    ANTENNAPARTIALMETALAREA 1.8492 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.3214 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 8.9658 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 40.2804 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 317.112 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1426.58 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 2.94444 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 5.048 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 22.7448 LAYER Metal5 ;
    ANTENNAGATEAREA 0.41265 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 329.345 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1481.7 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.90499 LAYER Via5 ;
  END store_addr_dmem[23]
  PIN store_addr_dmem[22] 
    ANTENNAPARTIALMETALAREA 2.2484 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.1178 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.9794 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 26.8416 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 209.331 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 942.646 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 2.94444 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 5.8592 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 26.424 LAYER Metal5 ;
    ANTENNAGATEAREA 0.41265 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 223.53 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1006.68 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.91178 LAYER Via5 ;
  END store_addr_dmem[22]
  PIN store_addr_dmem[21] 
    ANTENNAPARTIALMETALAREA 2.5372 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.4174 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.1664 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.6804 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 227.307 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1022.65 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 4.31197 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 3.5624 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 16.0596 LAYER Metal5 ;
    ANTENNAGATEAREA 0.4257 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 235.675 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1060.37 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.90584 LAYER Via5 ;
  END store_addr_dmem[21]
  PIN store_addr_dmem[20] 
    ANTENNAPARTIALMETALAREA 2.4092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.8414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.294 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.7888 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 187.064 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 841.662 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 3.05043 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 5.7584 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 25.9704 LAYER Metal5 ;
    ANTENNAGATEAREA 0.41265 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 241.365 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1089.34 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.46496 LAYER Via5 ;
  END store_addr_dmem[20]
  PIN store_addr_dmem[19] 
    ANTENNAPARTIALMETALAREA 2.9676 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.3542 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.382 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.1848 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 192.435 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 867.979 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 2.39402 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 1.8686 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 8.406 LAYER Metal5 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 256.319 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1155.36 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 2.72906 LAYER Via5 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.3812 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6812 LAYER Metal6 ;
    ANTENNAGATEAREA 0.43875 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 257.188 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1159.2 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.95254 LAYER Via6 ;
  END store_addr_dmem[19]
  PIN store_addr_dmem[18] 
    ANTENNAPARTIALMETALAREA 3.0628 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.7826 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.8864 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.9546 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 173.649 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 781.292 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 3.05043 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 4.3128 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 19.4364 LAYER Metal5 ;
    ANTENNAGATEAREA 0.43875 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 183.478 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 825.592 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.46097 LAYER Via5 ;
  END store_addr_dmem[18]
  PIN store_addr_dmem[17] 
    ANTENNAPARTIALMETALAREA 1.2092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.4414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.6372 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.8332 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 7.1696 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 32.3208 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.43875 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 33.623 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 169.728 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.49003 LAYER Via5 ;
  END store_addr_dmem[17]
  PIN store_addr_dmem[16] 
    ANTENNAPARTIALMETALAREA 1.1436 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1462 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.242 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.0548 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 7.0294 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 31.6584 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.38025 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 34.8974 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 159.134 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.90499 LAYER Via5 ;
  END store_addr_dmem[16]
  PIN store_addr_dmem[15] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1228 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5184 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.4576 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 42.6168 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4257 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 61.9676 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 283.933 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.46568 LAYER Via5 ;
  END store_addr_dmem[15]
  PIN store_addr_dmem[14] 
    ANTENNAPARTIALMETALAREA 2.0556 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.2502 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.8068 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5964 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 5.5976 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 25.218 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4257 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 130.367 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 587.67 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.44096 LAYER Via5 ;
  END store_addr_dmem[14]
  PIN store_addr_dmem[13] 
    ANTENNAPARTIALMETALAREA 0.9372 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2174 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.1412 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1012 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 6.2488 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 28.1484 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.39645 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 57.1608 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 261.628 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 6.48363 LAYER Via5 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 2.1414 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 9.6336 LAYER Metal6 ;
    ANTENNAGATEAREA 0.4257 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 62.1911 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 284.258 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.48363 LAYER Via6 ;
  END store_addr_dmem[13]
  PIN store_addr_dmem[12] 
    ANTENNAPARTIALMETALAREA 1.0012 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5054 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.9668 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.3164 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 7.9552 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 35.856 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.41265 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 53.4023 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 242.068 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.4418 LAYER Via5 ;
  END store_addr_dmem[12]
  PIN store_addr_dmem[11] 
    ANTENNAPARTIALMETALAREA 0.9692 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3614 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0564 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 7.4944 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 33.7536 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 28.1644 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 145.201 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via5 ;
    ANTENNAMAXCUTCAR 6.49886 LAYER Via5 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 8.4674 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 38.0664 LAYER Metal6 ;
    ANTENNAGATEAREA 0.43875 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 47.4633 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 231.962 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.49886 LAYER Via6 ;
  END store_addr_dmem[11]
  PIN store_addr_dmem[10] 
    ANTENNAPARTIALMETALAREA 0.0412 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1854 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.29 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2708 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 6.4504 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 29.0844 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4257 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 85.5157 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 385.614 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.48683 LAYER Via5 ;
  END store_addr_dmem[10]
  PIN store_addr_dmem[9] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0924 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3816 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.1934 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 41.4252 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.38025 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 101.282 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 456.573 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 6.54372 LAYER Via5 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 6.522 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 29.3148 LAYER Metal6 ;
    ANTENNAGATEAREA 0.43875 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 116.147 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 523.387 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.54372 LAYER Via6 ;
  END store_addr_dmem[9]
  PIN store_addr_dmem[8] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2292 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9972 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.1414 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 41.1912 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.38025 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 90.1884 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 405.865 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 6.54401 LAYER Via5 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 3.4174 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 15.3756 LAYER Metal6 ;
    ANTENNAGATEAREA 0.4257 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 119.751 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 541.254 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.54401 LAYER Via6 ;
  END store_addr_dmem[8]
  PIN store_addr_dmem[7] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0924 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3816 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 9.1784 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 41.3316 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.7538 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3552 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 34.9889 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 159.2 LAYER Metal6 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via6 ;
    ANTENNAMAXCUTCAR 3.72051 LAYER Via6 ;
    ANTENNAPARTIALMETALAREA 0.6616 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 3.006 LAYER Metal7 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 57.6077 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 261.969 LAYER Metal7 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via7 ;
    ANTENNAMAXCUTCAR 4.05556 LAYER Via7 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 3.8346 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 17.19 LAYER Metal8 ;
    ANTENNAGATEAREA 0.41265 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 223.972 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 1012.94 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.51709 LAYER Via8 ;
  END store_addr_dmem[7]
  PIN store_addr_dmem[6] 
    ANTENNAPARTIALMETALAREA 0.9212 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1454 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.4268 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8864 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 5.8168 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 26.2332 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.43875 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 216.383 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 974.97 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.44416 LAYER Via5 ;
  END store_addr_dmem[6]
  PIN store_addr_dmem[5] 
    ANTENNAPARTIALMETALAREA 0.1692 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7614 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1532 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6552 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 3.8664 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 17.4276 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 141.967 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 640.492 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 3.27949 LAYER Via5 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 8.248 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 37.0476 LAYER Metal6 ;
    ANTENNAGATEAREA 0.43875 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 160.766 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 724.931 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.5 LAYER Via6 ;
  END store_addr_dmem[5]
  PIN store_addr_dmem[4] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1076 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.45 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 6.1664 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 27.7776 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4257 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 57.6296 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 265.378 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.45891 LAYER Via5 ;
  END store_addr_dmem[4]
  PIN store_addr_dmem[3] 
    ANTENNAPARTIALMETALAREA 0.0572 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2574 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.5956 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.646 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.3848 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 33.2604 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 257.885 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1163.49 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 2.72906 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.1836 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 0.792 LAYER Metal6 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 264.162 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1190.56 LAYER Metal6 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via6 ;
    ANTENNAMAXCUTCAR 3.0641 LAYER Via6 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal7 ; 
    ANTENNAPARTIALMETALAREA 2.8104 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 12.6756 LAYER Metal7 ;
    ANTENNAGATEAREA 0.38025 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 271.552 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 1223.9 LAYER Metal7 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via7 ;
    ANTENNAMAXCUTCAR 6.54657 LAYER Via7 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 3.0572 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 13.7232 LAYER Metal8 ;
    ANTENNAGATEAREA 0.43875 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 278.52 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 1255.18 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.54657 LAYER Via8 ;
  END store_addr_dmem[3]
  PIN store_addr_dmem[2] 
    ANTENNAPARTIALMETALAREA 0.0252 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1134 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.3812 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6812 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.412 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 33.3828 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 264.332 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1191.14 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 3.27949 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.0924 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3816 LAYER Metal6 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 267.491 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1204.18 LAYER Metal6 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via6 ;
    ANTENNAMAXCUTCAR 3.61453 LAYER Via6 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal7 ; 
    ANTENNAPARTIALMETALAREA 3.6424 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 16.4196 LAYER Metal7 ;
    ANTENNAGATEAREA 0.38025 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 277.07 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 1247.37 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 6.94715 LAYER Via7 ;
  END store_addr_dmem[2]
  PIN store_addr_dmem[1] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.0164 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5738 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.7784 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 74.6255 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.32282 LAYER Via3 ;
  END store_addr_dmem[1]
  PIN store_addr_dmem[0] 
    ANTENNAPARTIALMETALAREA 2.7252 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.2634 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.1912 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.2632 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.16245 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 58.7049 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 265.401 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 3.95643 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.064 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 40.8168 LAYER Metal5 ;
    ANTENNAGATEAREA 0.57195 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 103.054 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 465.898 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.90328 LAYER Via5 ;
  END store_addr_dmem[0]
  PIN store_we_dmem[3] 
    ANTENNADIFFAREA 1.9348 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.1068 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0094 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.23625 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.1725 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 82.894 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.30815 LAYER Via3 ;
  END store_we_dmem[3]
  PIN store_we_dmem[2] 
    ANTENNADIFFAREA 1.9348 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9052 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0734 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.23625 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 21.9158 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 122.159 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.43005 LAYER Via3 ;
  END store_we_dmem[2]
  PIN store_we_dmem[1] 
    ANTENNADIFFAREA 1.9348 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.0652 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.7934 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.23625 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 21.7745 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 121.542 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.27778 LAYER Via3 ;
  END store_we_dmem[1]
  PIN store_we_dmem[0] 
    ANTENNADIFFAREA 1.9348 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.2292 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5602 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.23625 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.5898 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 84.9054 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.30815 LAYER Via3 ;
  END store_we_dmem[0]
  PIN d_store_dmem_m[31] 
    ANTENNAPARTIALMETALAREA 1.0812 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8654 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.9468 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.7264 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 19.7166 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 110.324 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.36486 LAYER Via4 ;
  END d_store_dmem_m[31]
  PIN d_store_dmem_m[30] 
    ANTENNAPARTIALMETALAREA 1.0172 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5774 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.6884 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5636 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 16.8477 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 97.3115 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41484 LAYER Via4 ;
  END d_store_dmem_m[30]
  PIN d_store_dmem_m[29] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9516 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2822 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.559 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 73.5354 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.3728 LAYER Via3 ;
  END d_store_dmem_m[29]
  PIN d_store_dmem_m[28] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.1516 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.6822 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 21.8722 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 119.945 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.3728 LAYER Via3 ;
  END d_store_dmem_m[28]
  PIN d_store_dmem_m[27] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.1132 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0094 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.2737 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 76.7503 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.37023 LAYER Via3 ;
  END d_store_dmem_m[27]
  PIN d_store_dmem_m[26] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.8898 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9726 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.2132 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 71.9781 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.37023 LAYER Via3 ;
  END d_store_dmem_m[26]
  PIN d_store_dmem_m[25] 
    ANTENNAPARTIALMETALAREA 1.1756 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2902 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8996 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.014 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.8915 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 88.4929 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.38396 LAYER Via4 ;
  END d_store_dmem_m[25]
  PIN d_store_dmem_m[24] 
    ANTENNAPARTIALMETALAREA 1.2244 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5098 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.9148 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0824 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.3031 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 76.9858 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.38846 LAYER Via4 ;
  END d_store_dmem_m[24]
  PIN d_store_dmem_m[23] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.3156 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.949 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.3162 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 81.5663 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.3728 LAYER Via3 ;
  END d_store_dmem_m[23]
  PIN d_store_dmem_m[22] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.4308 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.4386 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.5974 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 82.8108 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.32282 LAYER Via3 ;
  END d_store_dmem_m[22]
  PIN d_store_dmem_m[21] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.546 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.457 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 18.5946 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 105.196 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.3728 LAYER Via3 ;
  END d_store_dmem_m[21]
  PIN d_store_dmem_m[20] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.5764 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.0938 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 14.3672 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 86.1712 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.37023 LAYER Via3 ;
  END d_store_dmem_m[20]
  PIN d_store_dmem_m[19] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.1228 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0526 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.3175 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 76.9485 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.3728 LAYER Via3 ;
  END d_store_dmem_m[19]
  PIN d_store_dmem_m[18] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.222 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.499 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.335 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 81.5354 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.33677 LAYER Via3 ;
  END d_store_dmem_m[18]
  PIN d_store_dmem_m[17] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.502 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.259 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 18.2205 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 103.484 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.35907 LAYER Via3 ;
  END d_store_dmem_m[17]
  PIN d_store_dmem_m[16] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.8412 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7854 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.4088 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 72.8584 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.37023 LAYER Via3 ;
  END d_store_dmem_m[16]
  PIN d_store_dmem_m[15] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.8716 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9222 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.2132 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 71.9781 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.37023 LAYER Via3 ;
  END d_store_dmem_m[15]
  PIN d_store_dmem_m[14] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9372 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2174 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.0189 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 75.6049 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.3728 LAYER Via3 ;
  END d_store_dmem_m[14]
  PIN d_store_dmem_m[13] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.8594 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8358 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.4114 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 72.8713 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.3728 LAYER Via3 ;
  END d_store_dmem_m[13]
  PIN d_store_dmem_m[12] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.8898 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9726 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.2158 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 71.991 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.3728 LAYER Via3 ;
  END d_store_dmem_m[12]
  PIN d_store_dmem_m[11] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.8892 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0014 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.1214 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 80.565 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.37023 LAYER Via3 ;
  END d_store_dmem_m[11]
  PIN d_store_dmem_m[10] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.8732 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9294 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.5461 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 73.4762 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.37023 LAYER Via3 ;
  END d_store_dmem_m[10]
  PIN d_store_dmem_m[9] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.8564 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8538 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.148 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 71.6847 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.37023 LAYER Via3 ;
  END d_store_dmem_m[9]
  PIN d_store_dmem_m[8] 
    ANTENNAPARTIALMETALAREA 0.8092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.462 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.5448 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.2344 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 90.1544 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.36486 LAYER Via4 ;
  END d_store_dmem_m[8]
  PIN d_store_dmem_m[7] 
    ANTENNAPARTIALMETALAREA 1.1154 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.9878 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.899 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.5428 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3996 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.7102 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 84.6352 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.43079 LAYER Via4 ;
  END d_store_dmem_m[7]
  PIN d_store_dmem_m[6] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.8716 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9222 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.7349 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 74.3256 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.37023 LAYER Via3 ;
  END d_store_dmem_m[6]
  PIN d_store_dmem_m[5] 
    ANTENNAPARTIALMETALAREA 0.7292 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2814 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.444 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.9296 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 205.269 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 924.352 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 5.49074 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 4.6184 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 20.8116 LAYER Metal5 ;
    ANTENNAGATEAREA 0.3996 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 216.826 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 976.433 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.44302 LAYER Via5 ;
  END d_store_dmem_m[5]
  PIN d_store_dmem_m[4] 
    ANTENNAPARTIALMETALAREA 2.1044 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.4698 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.4696 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.5448 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3996 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 18.5663 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 98.2625 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.47133 LAYER Via4 ;
  END d_store_dmem_m[4]
  PIN d_store_dmem_m[3] 
    ANTENNAPARTIALMETALAREA 0.0252 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1134 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.5484 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4336 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 1.3064 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 5.9076 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 1.9932 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 8.9352 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3996 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 67.3827 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 305.024 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.48948 LAYER Via6 ;
  END d_store_dmem_m[3]
  PIN d_store_dmem_m[2] 
    ANTENNAPARTIALMETALAREA 1.8956 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.5302 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.6172 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.7432 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3996 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 63.2035 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 286.384 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.43364 LAYER Via4 ;
  END d_store_dmem_m[2]
  PIN d_store_dmem_m[1] 
    ANTENNADIFFAREA 2.4529 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.9462 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.221 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3996 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 24.974 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 130.472 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.46496 LAYER Via3 ;
  END d_store_dmem_m[1]
  PIN d_store_dmem_m[0] 
    ANTENNAPARTIALMETALAREA 2.2012 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.9054 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.8922 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.478 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3996 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 57.4069 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 258.165 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.44245 LAYER Via4 ;
  END d_store_dmem_m[0]
  PIN d_load_dmem[31] 
    ANTENNAPARTIALMETALAREA 0.0572 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2574 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.4316 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.408 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 1.0824 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8996 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 1.4452 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 6.4692 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 40.4362 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 186.457 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 4.83028 LAYER Via6 ;
  END d_load_dmem[31]
  PIN d_load_dmem[30] 
    ANTENNAPARTIALMETALAREA 0.8252 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7134 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 63.7007 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 289.453 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.40555 LAYER Via3 ;
  END d_load_dmem[30]
  PIN d_load_dmem[29] 
    ANTENNAPARTIALMETALAREA 1.3498 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.0714 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 109.372 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 493.21 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 2.39402 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.826 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.1828 LAYER Metal4 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 133.816 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 602.752 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.5679 LAYER Via4 ;
  END d_load_dmem[29]
  PIN d_load_dmem[28] 
    ANTENNAPARTIALMETALAREA 1.0416 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.653 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 110.09 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 495.077 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 2.94444 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.7196 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.704 LAYER Metal4 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 133.11 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 598.209 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.5679 LAYER Via4 ;
  END d_load_dmem[28]
  PIN d_load_dmem[27] 
    ANTENNAPARTIALMETALAREA 1.2016 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.373 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 127.396 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 573.026 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 3.56667 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.6488 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9484 LAYER Metal4 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 149.577 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 673.826 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 3.90171 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.2388 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0404 LAYER Metal5 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 152.774 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 687.753 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 4.78352 LAYER Via5 ;
  END d_load_dmem[27]
  PIN d_load_dmem[26] 
    ANTENNAPARTIALMETALAREA 0.9212 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1454 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.1744 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.6876 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 90.234 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 413.354 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.5679 LAYER Via4 ;
  END d_load_dmem[26]
  PIN d_load_dmem[25] 
    ANTENNAPARTIALMETALAREA 1.3956 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.309 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 161.815 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 729.979 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 4.61197 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.3226 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.9148 LAYER Metal4 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 179.521 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 809.16 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.61197 LAYER Via4 ;
  END d_load_dmem[25]
  PIN d_load_dmem[24] 
    ANTENNAPARTIALMETALAREA 1.1436 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1462 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.7194 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.1716 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.04545 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 116.905 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 533.229 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.5679 LAYER Via4 ;
  END d_load_dmem[24]
  PIN d_load_dmem[23] 
    ANTENNAPARTIALMETALAREA 0.7612 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4254 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.6068 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.6964 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 81.1365 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 364.97 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.09415 LAYER Via4 ;
  END d_load_dmem[23]
  PIN d_load_dmem[22] 
    ANTENNAPARTIALMETALAREA 1.0492 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.7214 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.9684 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.8236 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 65.1892 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 302.236 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.17858 LAYER Via4 ;
  END d_load_dmem[22]
  PIN d_load_dmem[21] 
    ANTENNAPARTIALMETALAREA 1.3356 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.0102 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.5716 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.038 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 95.8024 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 439.255 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.5679 LAYER Via4 ;
  END d_load_dmem[21]
  PIN d_load_dmem[20] 
    ANTENNAPARTIALMETALAREA 1.0812 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8654 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.5692 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.0272 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 102.573 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 467.777 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.5679 LAYER Via4 ;
  END d_load_dmem[20]
  PIN d_load_dmem[19] 
    ANTENNAPARTIALMETALAREA 1.6172 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.3062 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 199.159 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 898.595 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 2.6735 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.67 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9808 LAYER Metal4 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 208.128 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 938.498 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.17858 LAYER Via4 ;
  END d_load_dmem[19]
  PIN d_load_dmem[18] 
    ANTENNAPARTIALMETALAREA 0.9196 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1382 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.2552 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.0512 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 139.225 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 633.814 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.5679 LAYER Via4 ;
  END d_load_dmem[18]
  PIN d_load_dmem[17] 
    ANTENNAPARTIALMETALAREA 1.2092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.4414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.0658 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.7304 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 94.6538 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 425.651 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 3.82991 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.7304 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3156 LAYER Metal5 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 106.08 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 484.237 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.17284 LAYER Via5 ;
  END d_load_dmem[17]
  PIN d_load_dmem[16] 
    ANTENNAPARTIALMETALAREA 1.8012 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.1054 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 7.0186 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.518 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.04545 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 172.777 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 779.281 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.5679 LAYER Via4 ;
  END d_load_dmem[16]
  PIN d_load_dmem[15] 
    ANTENNAPARTIALMETALAREA 0.8564 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8538 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.522 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.3148 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 86.6652 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 391.036 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 3.36724 LAYER Via4 ;
  END d_load_dmem[15]
  PIN d_load_dmem[14] 
    ANTENNAPARTIALMETALAREA 0.7292 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2814 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 120.462 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 544.359 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.46752 LAYER Via3 ;
  END d_load_dmem[14]
  PIN d_load_dmem[13] 
    ANTENNAPARTIALMETALAREA 1.2516 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.661 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 214.035 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 965.272 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 2.39402 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.4286 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.426 LAYER Metal4 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 238.456 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1075.12 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.92735 LAYER Via4 ;
  END d_load_dmem[13]
  PIN d_load_dmem[12] 
    ANTENNAPARTIALMETALAREA 1.093 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.9158 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 246.886 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 1111.81 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 5.28291 LAYER Via3 ;
  END d_load_dmem[12]
  PIN d_load_dmem[11] 
    ANTENNAPARTIALMETALAREA 0.7932 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5694 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.6026 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.646 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 135.621 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 613.569 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 3.64188 LAYER Via4 ;
  END d_load_dmem[11]
  PIN d_load_dmem[10] 
    ANTENNAPARTIALMETALAREA 1.0722 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.851 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 242.989 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 1094.29 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 4.57863 LAYER Via3 ;
  END d_load_dmem[10]
  PIN d_load_dmem[9] 
    ANTENNAPARTIALMETALAREA 1.3188 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.9346 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.8416 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.7188 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 170.287 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 768.79 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.07521 LAYER Via4 ;
  END d_load_dmem[9]
  PIN d_load_dmem[8] 
    ANTENNAPARTIALMETALAREA 0.7292 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2814 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.9004 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.0176 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.04545 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 171.053 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 774.911 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.74649 LAYER Via4 ;
  END d_load_dmem[8]
  PIN d_load_dmem[7] 
    ANTENNAPARTIALMETALAREA 0.9052 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0734 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0382 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1692 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0494 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 8.1454 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 36.6516 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 153.361 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 691.179 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 2.52991 LAYER Via6 ;
  END d_load_dmem[7]
  PIN d_load_dmem[6] 
    ANTENNAPARTIALMETALAREA 1.0172 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5774 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.5086 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.286 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 230.369 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1038.23 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 3.35385 LAYER Via4 ;
  END d_load_dmem[6]
  PIN d_load_dmem[5] 
    ANTENNAPARTIALMETALAREA 0.8252 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7134 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.9636 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.802 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 245.904 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1108.13 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.36239 LAYER Via4 ;
  END d_load_dmem[5]
  PIN d_load_dmem[4] 
    ANTENNAPARTIALMETALAREA 1.0804 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8618 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.5332 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.8652 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 241.61 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1088.81 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.36239 LAYER Via4 ;
  END d_load_dmem[4]
  PIN d_load_dmem[3] 
    ANTENNAPARTIALMETALAREA 1.1452 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1534 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 7.5724 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.0416 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 267.429 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1204.99 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.36239 LAYER Via4 ;
  END d_load_dmem[3]
  PIN d_load_dmem[2] 
    ANTENNAPARTIALMETALAREA 0.7612 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4254 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.9092 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.5572 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 263.484 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1187.15 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 3.35385 LAYER Via4 ;
  END d_load_dmem[2]
  PIN d_load_dmem[1] 
    ANTENNAPARTIALMETALAREA 0.8732 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9294 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.6156 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.736 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 268.155 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1208.57 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.76838 LAYER Via4 ;
  END d_load_dmem[1]
  PIN d_load_dmem[0] 
    ANTENNAPARTIALMETALAREA 0.9886 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4172 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 8.024 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.1368 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 282.507 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1274.38 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.05897 LAYER Via4 ;
  END d_load_dmem[0]
  PIN trace_pc[31] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.847 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.78 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.1471 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 89.6641 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.40197 LAYER Via4 ;
  END trace_pc[31]
  PIN trace_pc[30] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.2636 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.652 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 21.9648 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 120.202 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[30]
  PIN trace_pc[29] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0566 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2232 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.3239 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 81.4659 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41484 LAYER Via4 ;
  END trace_pc[29]
  PIN trace_pc[28] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.1167 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 76.0322 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[28]
  PIN trace_pc[27] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.3616 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 72.6345 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[27]
  PIN trace_pc[26] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.4303 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 72.9434 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[26]
  PIN trace_pc[25] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.8421 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 74.7967 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[25]
  PIN trace_pc[24] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7558 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3696 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.7452 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 74.3616 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41484 LAYER Via4 ;
  END trace_pc[24]
  PIN trace_pc[23] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.4552 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 73.0644 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.37881 LAYER Via4 ;
  END trace_pc[23]
  PIN trace_pc[22] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.4303 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 72.9434 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[22]
  PIN trace_pc[21] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.254 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 76.6499 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[21]
  PIN trace_pc[20] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.5676 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 73.5611 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[20]
  PIN trace_pc[19] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.4303 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 72.9434 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[19]
  PIN trace_pc[18] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.5972 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 78.1943 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[18]
  PIN trace_pc[17] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0566 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2232 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.3831 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 90.7323 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41484 LAYER Via4 ;
  END trace_pc[17]
  PIN trace_pc[16] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.6362 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 73.87 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[16]
  PIN trace_pc[15] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.3239 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 81.4659 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41484 LAYER Via4 ;
  END trace_pc[15]
  PIN trace_pc[14] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0566 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2232 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.5285 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 77.8855 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[14]
  PIN trace_pc[13] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.9108 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 75.1055 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[13]
  PIN trace_pc[12] 
    ANTENNAPARTIALMETALAREA 0.923 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.122 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 3.9624 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 17.8596 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 32.4676 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 167.723 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.45431 LAYER Via5 ;
  END trace_pc[12]
  PIN trace_pc[11] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8774 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9168 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.0766 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 80.4556 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.36486 LAYER Via4 ;
  END trace_pc[11]
  PIN trace_pc[10] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.254 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 76.6499 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[10]
  PIN trace_pc[9] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8622 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8484 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.896 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 75.1429 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.36486 LAYER Via4 ;
  END trace_pc[9]
  PIN trace_pc[8] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.6268 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 82.8275 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[8]
  PIN trace_pc[7] 
    ANTENNAPARTIALMETALAREA 0.9838 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3956 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 3.4184 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 15.4116 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 27.6422 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 146.009 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.45431 LAYER Via5 ;
  END trace_pc[7]
  PIN trace_pc[6] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.4989 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 73.2523 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[6]
  PIN trace_pc[5] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.293 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 72.3256 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[5]
  PIN trace_pc[4] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.087 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.36 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.4408 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 73.0103 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.37645 LAYER Via4 ;
  END trace_pc[4]
  PIN trace_pc[3] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.7146 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.65 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 17.4577 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 99.9215 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41484 LAYER Via4 ;
  END trace_pc[3]
  PIN trace_pc[2] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.6574 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.4268 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 17.4294 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 99.9395 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[2]
  PIN trace_pc[1] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.1167 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 76.0322 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_pc[1]
  PIN trace_pc[0] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8622 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8484 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.9166 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 75.2355 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.36486 LAYER Via4 ;
  END trace_pc[0]
  PIN trace_inst[31] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.048 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 75.7233 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_inst[31]
  PIN trace_inst[30] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.5676 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 73.5611 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_inst[30]
  PIN trace_inst[29] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.4989 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 73.2523 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_inst[29]
  PIN trace_inst[28] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.3238 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.4256 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 18.0944 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 102.933 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41484 LAYER Via4 ;
  END trace_inst[28]
  PIN trace_inst[27] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.4989 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 73.2523 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_inst[27]
  PIN trace_inst[26] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.847 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.78 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.2347 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 72.0579 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.40197 LAYER Via4 ;
  END trace_inst[26]
  PIN trace_inst[25] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8166 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6432 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.7735 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 74.4878 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_inst[25]
  PIN trace_inst[24] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.7286 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.7472 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.3623 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 90.6165 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.38546 LAYER Via4 ;
  END trace_inst[24]
  PIN trace_inst[23] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8014 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5748 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.1557 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 71.7079 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_inst[23]
  PIN trace_inst[22] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.7136 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.2112 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 19.2048 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 108.084 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.37645 LAYER Via4 ;
  END trace_inst[22]
  PIN trace_inst[21] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8318 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7116 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.1557 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 71.7079 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_inst[21]
  PIN trace_inst[20] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.293 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 72.3256 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_inst[20]
  PIN trace_inst[19] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.2574 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6268 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.4728 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 82.0528 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.39897 LAYER Via4 ;
  END trace_inst[19]
  PIN trace_inst[18] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.4094 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.3108 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.9399 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 84.2458 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.37881 LAYER Via4 ;
  END trace_inst[18]
  PIN trace_inst[17] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7558 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3696 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.1557 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 71.7079 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_inst[17]
  PIN trace_inst[16] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.9056 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0752 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.7864 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 74.547 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41484 LAYER Via4 ;
  END trace_inst[16]
  PIN trace_inst[15] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.7297 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 74.2999 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.37881 LAYER Via4 ;
  END trace_inst[15]
  PIN trace_inst[14] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.847 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.78 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.2347 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 72.0579 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.40197 LAYER Via4 ;
  END trace_inst[14]
  PIN trace_inst[13] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.92 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.14 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.7177 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 74.2381 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41484 LAYER Via4 ;
  END trace_inst[13]
  PIN trace_inst[12] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.3942 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2424 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.5822 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 82.6216 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.40197 LAYER Via4 ;
  END trace_inst[12]
  PIN trace_inst[11] 
    ANTENNAPARTIALMETALAREA 2.8838 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.9456 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 10.7856 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 48.5928 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3996 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 62.2996 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 283.011 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 6.5413 LAYER Via5 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 1.2354 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 5.4936 LAYER Metal6 ;
    ANTENNAGATEAREA 0.54585 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 64.5629 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 293.075 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.5413 LAYER Via6 ;
  END trace_inst[11]
  PIN trace_inst[10] 
    ANTENNAPARTIALMETALAREA 2.7774 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4668 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 5.0952 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 22.9572 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 163.164 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 737.75 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 3.31173 LAYER Via5 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 1.7498 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 7.8372 LAYER Metal6 ;
    ANTENNAGATEAREA 0.6984 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 165.669 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 748.972 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.95811 LAYER Via6 ;
  END trace_inst[10]
  PIN trace_inst[9] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.5678 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.0236 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 36.3715 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 185.188 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.37881 LAYER Via4 ;
  END trace_inst[9]
  PIN trace_inst[8] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.6526 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.4052 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 22.7327 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 123.813 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.37881 LAYER Via4 ;
  END trace_inst[8]
  PIN trace_inst[7] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.7894 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.0208 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 30.9436 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 160.732 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.38546 LAYER Via4 ;
  END trace_inst[7]
  PIN trace_inst[6] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.847 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.78 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.2347 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 72.0579 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.40197 LAYER Via4 ;
  END trace_inst[6]
  PIN trace_inst[5] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.847 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.78 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.2347 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 72.0579 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.40197 LAYER Via4 ;
  END trace_inst[5]
  PIN trace_inst[4] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.3758 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6596 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.2244 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 72.0167 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.41227 LAYER Via4 ;
  END trace_inst[4]
  PIN trace_inst[3] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.4552 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 73.0644 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.37881 LAYER Via4 ;
  END trace_inst[3]
  PIN trace_inst[2] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.0729 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 75.8443 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.37881 LAYER Via4 ;
  END trace_inst[2]
  PIN trace_inst[1] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0566 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2232 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.3449 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 86.0682 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.37881 LAYER Via4 ;
  END trace_inst[1]
  PIN trace_inst[0] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.0546 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.7142 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.4305 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 90.964 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.37645 LAYER Via4 ;
  END trace_inst[0]
END datapath

END LIBRARY
