

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO datapath 
  PIN clk 
    ANTENNAPARTIALMETALAREA 0.0274 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0918 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 14.6068 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 65.6172 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2466 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 252.872 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1142.64 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.23765 LAYER Via4 ;
  END clk
  PIN rst_n 
    ANTENNAPARTIALMETALAREA 5.3778 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.1002 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 178.968 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 805.908 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAMAXCUTCAR 3.03248 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.571 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.0956 LAYER Metal4 ;
    ANTENNAGATEAREA 0.117 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 226.583 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1020.4 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAMAXCUTCAR 3.2 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 17.2066 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 77.1984 LAYER Metal5 ;
    ANTENNAGATEAREA 0.78975 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 248.37 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1118.15 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 3.2 LAYER Via5 ;
  END rst_n
  PIN c_pc_f[31] 
    ANTENNAPARTIALMETALAREA 0.9874 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4118 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 9.7664 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 43.9776 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 41.7215 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 207.788 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.86624 LAYER Via4 ;
  END c_pc_f[31]
  PIN c_pc_f[30] 
    ANTENNAPARTIALMETALAREA 5.9786 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.8722 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 5.2624 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.7384 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 21.9181 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 118.844 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.86624 LAYER Via4 ;
  END c_pc_f[30]
  PIN c_pc_f[29] 
    ANTENNAPARTIALMETALAREA 0.9386 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1922 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 10.1008 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 45.4824 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 38.6828 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 194.078 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87707 LAYER Via4 ;
  END c_pc_f[29]
  PIN c_pc_f[28] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 6.3266 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 28.4382 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 24.9113 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 132.032 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.84915 LAYER Via3 ;
  END c_pc_f[28]
  PIN c_pc_f[27] 
    ANTENNAPARTIALMETALAREA 0.0594 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2358 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.3616 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.656 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 6.3798 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 28.7064 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 25.851 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 136.256 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.88575 LAYER Via5 ;
  END c_pc_f[27]
  PIN c_pc_f[26] 
    ANTENNAPARTIALMETALAREA 2.8082 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.6054 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2232 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0332 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 3.7108 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 16.6644 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 19.5711 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 108.014 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.89416 LAYER Via5 ;
  END c_pc_f[26]
  PIN c_pc_f[25] 
    ANTENNAPARTIALMETALAREA 2.7626 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4002 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.056 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2808 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 4.2548 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 19.1124 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 31.5607 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 163.502 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.44402 LAYER Via5 ;
  END c_pc_f[25]
  PIN c_pc_f[24] 
    ANTENNAPARTIALMETALAREA 0.7778 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4686 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.2384 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.1016 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 30.6281 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 157.832 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87707 LAYER Via4 ;
  END c_pc_f[24]
  PIN c_pc_f[23] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.4334 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.3846 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 18.6514 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 103.765 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.84915 LAYER Via3 ;
  END c_pc_f[23]
  PIN c_pc_f[22] 
    ANTENNAPARTIALMETALAREA 1.0514 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6998 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 7.5152 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 33.8472 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 30.0808 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 155.374 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.86083 LAYER Via4 ;
  END c_pc_f[22]
  PIN c_pc_f[21] 
    ANTENNAPARTIALMETALAREA 1.4514 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.4998 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0408 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2124 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 6.2548 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 28.1124 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 27.4685 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 143.606 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.90499 LAYER Via5 ;
  END c_pc_f[21]
  PIN c_pc_f[20] 
    ANTENNAPARTIALMETALAREA 3.0154 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.5378 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1472 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6912 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 4.2708 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 19.1844 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 22.2956 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 120.332 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.89274 LAYER Via5 ;
  END c_pc_f[20]
  PIN c_pc_f[19] 
    ANTENNAPARTIALMETALAREA 1.4354 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.4278 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.5288 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4084 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 5.995 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 26.9748 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 25.446 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 134.598 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.89274 LAYER Via5 ;
  END c_pc_f[19]
  PIN c_pc_f[18] 
    ANTENNAPARTIALMETALAREA 0.0594 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2358 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.5896 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.682 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 7.4868 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 33.6564 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 29.9842 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 154.837 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.90499 LAYER Via5 ;
  END c_pc_f[18]
  PIN c_pc_f[17] 
    ANTENNAPARTIALMETALAREA 0.0914 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3798 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.6656 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.024 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 7.9638 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 35.8344 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 29.7688 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 153.956 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.90328 LAYER Via5 ;
  END c_pc_f[17]
  PIN c_pc_f[16] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.0178 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5486 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 25.7717 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 135.985 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.84915 LAYER Via3 ;
  END c_pc_f[16]
  PIN c_pc_f[15] 
    ANTENNAPARTIALMETALAREA 1.1154 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.9878 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 5.0528 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.7664 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 23.0041 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 123.517 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.86339 LAYER Via4 ;
  END c_pc_f[15]
  PIN c_pc_f[14] 
    ANTENNAPARTIALMETALAREA 0.0754 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3078 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.3904 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7856 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 7.575 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 34.0848 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 28.6436 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 148.912 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.88575 LAYER Via5 ;
  END c_pc_f[14]
  PIN c_pc_f[13] 
    ANTENNAPARTIALMETALAREA 0.0594 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2358 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1016 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.486 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 5.927 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 26.6688 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 23.9745 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 128.001 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.88447 LAYER Via5 ;
  END c_pc_f[13]
  PIN c_pc_f[12] 
    ANTENNAPARTIALMETALAREA 0.0594 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2358 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2856 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.314 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 7.4516 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 33.498 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 28.2486 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 147.152 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.89416 LAYER Via5 ;
  END c_pc_f[12]
  PIN c_pc_f[11] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.8662 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.3322 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.2301 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 74.9624 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.83689 LAYER Via3 ;
  END c_pc_f[11]
  PIN c_pc_f[10] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.1062 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.4122 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 17.7876 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 99.9479 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.84687 LAYER Via3 ;
  END c_pc_f[10]
  PIN c_pc_f[9] 
    ANTENNAPARTIALMETALAREA 0.1234 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5238 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1168 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5544 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 7.9156 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 35.586 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 32.5711 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 166.636 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.90214 LAYER Via5 ;
  END c_pc_f[9]
  PIN c_pc_f[8] 
    ANTENNAPARTIALMETALAREA 0.0434 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1638 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.208 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9648 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 7.8524 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 35.3016 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 31.7506 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 162.785 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.90499 LAYER Via5 ;
  END c_pc_f[8]
  PIN c_pc_f[7] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0438 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1944 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 7.3076 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 32.85 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 30.9802 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 159.437 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.88447 LAYER Via5 ;
  END c_pc_f[7]
  PIN c_pc_f[6] 
    ANTENNAPARTIALMETALAREA 1.4026 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2802 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0712 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3492 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 6.1732 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 27.7452 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 26.0184 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 137.109 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.88447 LAYER Via5 ;
  END c_pc_f[6]
  PIN c_pc_f[5] 
    ANTENNAPARTIALMETALAREA 2.6498 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.8926 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.7872 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5712 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 1.3748 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.1524 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 11.9494 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 73.7162 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.89416 LAYER Via5 ;
  END c_pc_f[5]
  PIN c_pc_f[4] 
    ANTENNAPARTIALMETALAREA 1.5458 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.9246 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0712 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3492 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 5.8996 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 26.514 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 24.7044 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 131.203 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.89416 LAYER Via5 ;
  END c_pc_f[4]
  PIN c_pc_f[3] 
    ANTENNAPARTIALMETALAREA 0.0434 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1638 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2232 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0332 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 8.058 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 36.2268 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 30.2771 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 156.291 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.8594 LAYER Via5 ;
  END c_pc_f[3]
  PIN c_pc_f[2] 
    ANTENNAPARTIALMETALAREA 0.0434 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1638 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2384 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1016 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 7.127 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 32.0688 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 27.3848 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 143.228 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.90328 LAYER Via5 ;
  END c_pc_f[2]
  PIN c_pc_f[1] 
    ANTENNAPARTIALMETALAREA 0.0434 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1638 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1624 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7596 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 4.0148 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 18.0324 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 22.187 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 119.868 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.88447 LAYER Via5 ;
  END c_pc_f[1]
  PIN c_pc_f[0] 
    ANTENNAPARTIALMETALAREA 0.0434 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1638 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.056 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2808 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 4.1404 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 18.5976 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 21.3511 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 115.987 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.90328 LAYER Via5 ;
  END c_pc_f[0]
  PIN f_inst[31] 
    ANTENNAPARTIALMETALAREA 2.3762 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.6614 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0256 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.144 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.0924 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 31.8816 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1332 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 143.141 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 649.35 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 4.08661 LAYER Via5 ;
  END f_inst[31]
  PIN f_inst[30] 
    ANTENNAPARTIALMETALAREA 1.3874 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2118 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2232 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0332 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 9.3764 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 42.0624 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.19485 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 110.936 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 503.704 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.17284 LAYER Via5 ;
  END f_inst[30]
  PIN f_inst[29] 
    ANTENNAPARTIALMETALAREA 4.1834 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.7938 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0408 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2124 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 6.1486 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 27.5688 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0648 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 217.701 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 985.944 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 4.87037 LAYER Via5 ;
  END f_inst[29]
  PIN f_inst[28] 
    ANTENNAPARTIALMETALAREA 3.2738 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.7006 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0398 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1764 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.1114 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 31.9356 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0648 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 246.157 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1110.44 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.16667 LAYER Via5 ;
  END f_inst[28]
  PIN f_inst[27] 
    ANTENNAPARTIALMETALAREA 1.3874 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2118 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0864 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4176 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.9858 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 35.8992 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.07785 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 209.357 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 945.67 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.20988 LAYER Via5 ;
  END f_inst[27]
  PIN f_inst[26] 
    ANTENNAPARTIALMETALAREA 2.1866 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.8082 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0398 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1764 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 6.597 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 29.6496 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.07785 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 174.956 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 790.059 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.60494 LAYER Via5 ;
  END f_inst[26]
  PIN f_inst[25] 
    ANTENNAPARTIALMETALAREA 0.1714 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7398 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0712 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3492 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 10.1062 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 45.3096 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1656 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 171.96 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 776.553 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.16667 LAYER Via5 ;
  END f_inst[25]
  PIN f_inst[24] 
    ANTENNAPARTIALMETALAREA 0.0434 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1638 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2384 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1016 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 12.2274 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 54.9864 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.62055 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 114.426 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 522.683 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.5679 LAYER Via5 ;
  END f_inst[24]
  PIN f_inst[23] 
    ANTENNAPARTIALMETALAREA 1.5474 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.9318 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.6352 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8872 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 15.1174 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 67.86 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 150.74 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 683.736 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.77778 LAYER Via5 ;
  END f_inst[23]
  PIN f_inst[22] 
    ANTENNAPARTIALMETALAREA 1.0834 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8438 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.3592 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.1452 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 13.1374 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 58.95 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3573 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 128.096 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 584.395 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.77778 LAYER Via5 ;
  END f_inst[22]
  PIN f_inst[21] 
    ANTENNAPARTIALMETALAREA 1.4194 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.3558 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.0704 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8456 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 11.6742 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 52.434 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.32805 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 158.173 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 719.909 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.5679 LAYER Via5 ;
  END f_inst[21]
  PIN f_inst[20] 
    ANTENNAPARTIALMETALAREA 0.0434 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1638 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.132 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6228 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 13.0424 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 58.6224 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.5427 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 71.1838 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 322.154 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.74541 LAYER Via5 ;
  END f_inst[20]
  PIN f_inst[19] 
    ANTENNAPARTIALMETALAREA 0.8114 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6198 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.8064 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.1576 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 14.9422 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 67.0032 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.5004 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 111.097 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 503.862 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.77778 LAYER Via5 ;
  END f_inst[19]
  PIN f_inst[18] 
    ANTENNAPARTIALMETALAREA 1.1778 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2686 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.2792 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.2852 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 11.8782 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 53.2836 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.35415 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 81.1908 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 369.376 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.17284 LAYER Via5 ;
  END f_inst[18]
  PIN f_inst[17] 
    ANTENNAPARTIALMETALAREA 1.2266 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.4882 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.7656 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.474 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 14.2206 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 63.8244 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.42885 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 88.7011 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 400.933 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.17284 LAYER Via5 ;
  END f_inst[17]
  PIN f_inst[16] 
    ANTENNAPARTIALMETALAREA 0.0754 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3078 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.284 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3068 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 17.345 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 77.9184 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3411 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 367.116 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1660.06 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.77778 LAYER Via5 ;
  END f_inst[16]
  PIN f_inst[15] 
    ANTENNAPARTIALMETALAREA 0.0434 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1638 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.4512 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0592 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 20.433 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 91.872 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.47115 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 94.7232 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 432.706 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.17284 LAYER Via5 ;
  END f_inst[15]
  PIN f_inst[14] 
    ANTENNAPARTIALMETALAREA 0.7474 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3318 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.6912 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.6392 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 6.7346 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 30.24 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2664 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 53.2014 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 246.203 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 10.6111 LAYER Via5 ;
  END f_inst[14]
  PIN f_inst[13] 
    ANTENNAPARTIALMETALAREA 0.9554 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2678 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.6168 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.3044 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 6.5172 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 29.2248 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3573 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 192.962 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 871.627 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.37654 LAYER Via5 ;
  END f_inst[13]
  PIN f_inst[12] 
    ANTENNAPARTIALMETALAREA 1.0194 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5558 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.2352 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.5872 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.8208 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 35.1252 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3249 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 125.059 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 568.092 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 4.8642 LAYER Via5 ;
  END f_inst[12]
  PIN f_inst[11] 
    ANTENNAPARTIALMETALAREA 1.3394 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.9958 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.4176 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.408 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 11.2698 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 50.6484 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.37035 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 92.484 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 419.937 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.33014 LAYER Via5 ;
  END f_inst[11]
  PIN f_inst[10] 
    ANTENNAPARTIALMETALAREA 1.3058 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.8446 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.6472 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.4412 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 12.1424 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 54.5436 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2826 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 78.9553 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 363.245 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.13579 LAYER Via5 ;
  END f_inst[10]
  PIN f_inst[9] 
    ANTENNAPARTIALMETALAREA 1.3866 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2082 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.936 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 26.7408 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 11.1818 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 50.2524 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.31185 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 88.4258 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 407.31 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.48302 LAYER Via5 ;
  END f_inst[9]
  PIN f_inst[8] 
    ANTENNAPARTIALMETALAREA 1.3074 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.8518 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.1336 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.63 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 13.0704 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 58.7772 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.32805 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 71.5601 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 331.045 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 8.28085 LAYER Via5 ;
  END f_inst[8]
  PIN f_inst[7] 
    ANTENNAPARTIALMETALAREA 1.2434 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5638 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 7.184 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 32.3568 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 14.03 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 62.964 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.39645 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 64.005 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 288.066 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.78746 LAYER Via5 ;
  END f_inst[7]
  PIN f_inst[6] 
    ANTENNAPARTIALMETALAREA 1.1154 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.9878 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 8.4136 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 37.89 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 2.8686 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 12.8376 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3411 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 199.07 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 897.617 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 8.11728 LAYER Via5 ;
  END f_inst[6]
  PIN f_inst[5] 
    ANTENNAPARTIALMETALAREA 1.1794 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2758 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 9.0216 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 40.626 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 5.2794 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 23.6916 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.38655 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 50.0343 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 231.049 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.90741 LAYER Via5 ;
  END f_inst[5]
  PIN f_inst[4] 
    ANTENNAPARTIALMETALAREA 1.0026 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4802 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 8.9928 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 40.4964 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 4.4916 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 20.1096 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.35415 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 147.516 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 669.431 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 8.11728 LAYER Via5 ;
  END f_inst[4]
  PIN f_inst[3] 
    ANTENNAPARTIALMETALAREA 1.0514 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6998 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 9.1432 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 41.1732 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 3.2686 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 14.6376 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2403 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 181.392 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 821.858 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.08025 LAYER Via5 ;
  END f_inst[3]
  PIN f_inst[2] 
    ANTENNAPARTIALMETALAREA 2.6478 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.8494 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.812 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6828 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 61.2531 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 280.13 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 7.64815 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 4.1532 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 18.6552 LAYER Metal5 ;
    ANTENNAGATEAREA 0.42885 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 70.9376 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 323.63 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.64815 LAYER Via5 ;
  END f_inst[2]
  PIN f_inst[1] 
    ANTENNAPARTIALMETALAREA 0.9234 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1238 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 10.0704 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 45.3456 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 177.33 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 801.731 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.09572 LAYER Via4 ;
  END f_inst[1]
  PIN f_inst[0] 
    ANTENNAPARTIALMETALAREA 2.1542 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.6282 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 62.2029 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 284.076 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 11.9466 LAYER Via3 ;
  END f_inst[0]
  PIN store_addr_dmem[31] 
    ANTENNADIFFAREA 1.65 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 5.0026 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.4802 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 32.4616 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 167.605 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.33677 LAYER Via3 ;
  END store_addr_dmem[31]
  PIN store_addr_dmem[30] 
    ANTENNAPARTIALMETALAREA 3.0194 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.5558 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 4.2944 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.3536 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 19.6793 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 108.652 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87707 LAYER Via4 ;
  END store_addr_dmem[30]
  PIN store_addr_dmem[29] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.9954 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.9478 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 20.6873 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 113.092 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.8463 LAYER Via3 ;
  END store_addr_dmem[29]
  PIN store_addr_dmem[28] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 4.0274 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.0918 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 19.3493 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 107.084 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.8416 LAYER Via3 ;
  END store_addr_dmem[28]
  PIN store_addr_dmem[27] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.8034 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.0838 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 18.2979 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 102.272 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.85 LAYER Via3 ;
  END store_addr_dmem[27]
  PIN store_addr_dmem[26] 
    ANTENNAPARTIALMETALAREA 2.7154 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1878 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.612 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.2828 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 17.8697 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 100.418 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87536 LAYER Via4 ;
  END store_addr_dmem[26]
  PIN store_addr_dmem[25] 
    ANTENNAPARTIALMETALAREA 2.5074 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.2518 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.5968 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.2144 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 18.4812 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 103.232 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.8567 LAYER Via4 ;
  END store_addr_dmem[25]
  PIN store_addr_dmem[24] 
    ANTENNAPARTIALMETALAREA 0.9554 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2678 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.2608 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.7024 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 16.8999 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 96.1231 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87422 LAYER Via4 ;
  END store_addr_dmem[24]
  PIN store_addr_dmem[23] 
    ANTENNAPARTIALMETALAREA 2.5698 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.5326 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.004 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.5468 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 16.7416 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 95.3889 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.85157 LAYER Via4 ;
  END store_addr_dmem[23]
  PIN store_addr_dmem[22] 
    ANTENNAPARTIALMETALAREA 0.0434 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1638 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.208 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9648 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 4.0948 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 18.3924 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 20.3272 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 111.38 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.90499 LAYER Via5 ;
  END store_addr_dmem[22]
  PIN store_addr_dmem[21] 
    ANTENNAPARTIALMETALAREA 1.0498 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6926 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.9432 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.2732 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 10.4132 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 46.8252 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 58.6023 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 285.08 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.36251 LAYER Via5 ;
  END store_addr_dmem[21]
  PIN store_addr_dmem[20] 
    ANTENNAPARTIALMETALAREA 0.9874 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4118 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.9968 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.5144 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.4529 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 10.8092 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 48.6072 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 38.9772 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 193.683 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.46211 LAYER Via5 ;
  END store_addr_dmem[20]
  PIN store_addr_dmem[19] 
    ANTENNAPARTIALMETALAREA 2.6346 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.8242 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.4984 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2716 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 8.774 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 39.3804 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 45.8945 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 227.6 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.35993 LAYER Via5 ;
  END store_addr_dmem[19]
  PIN store_addr_dmem[18] 
    ANTENNAPARTIALMETALAREA 1.0514 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6998 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.2832 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.8032 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 10.1194 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 45.5004 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 50.9513 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 250.741 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.31253 LAYER Via5 ;
  END store_addr_dmem[18]
  PIN store_addr_dmem[17] 
    ANTENNAPARTIALMETALAREA 0.9234 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1238 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.4176 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.908 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 4.2844 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 19.2456 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 30.1555 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 157.474 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.37645 LAYER Via5 ;
  END store_addr_dmem[17]
  PIN store_addr_dmem[16] 
    ANTENNAPARTIALMETALAREA 0.8914 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9798 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.7928 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.0964 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.8268 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 44.1864 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 51.4603 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 252.941 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.36251 LAYER Via5 ;
  END store_addr_dmem[16]
  PIN store_addr_dmem[15] 
    ANTENNAPARTIALMETALAREA 0.8274 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6918 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 4.3568 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.6344 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 22.0383 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 119.177 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87536 LAYER Via4 ;
  END store_addr_dmem[15]
  PIN store_addr_dmem[14] 
    ANTENNAPARTIALMETALAREA 0.0434 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1638 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.8808 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.5212 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.6388 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 43.3404 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 51.4157 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 252.74 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.36251 LAYER Via5 ;
  END store_addr_dmem[14]
  PIN store_addr_dmem[13] 
    ANTENNAPARTIALMETALAREA 0.7786 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4722 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.4416 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.516 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 18.1024 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 101.467 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END store_addr_dmem[13]
  PIN store_addr_dmem[12] 
    ANTENNAPARTIALMETALAREA 0.0754 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3078 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.4376 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.998 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.3732 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 42.1452 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 59.9577 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 291.282 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.31253 LAYER Via5 ;
  END store_addr_dmem[12]
  PIN store_addr_dmem[11] 
    ANTENNAPARTIALMETALAREA 0.0434 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1638 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2384 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1016 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 1.65 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 10.364 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 46.5696 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 56.0103 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 273.268 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 7.35993 LAYER Via5 ;
  END store_addr_dmem[11]
  PIN store_addr_dmem[10] 
    ANTENNAPARTIALMETALAREA 0.9554 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2678 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.8624 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9096 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 2.7954 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 12.5424 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 15.197 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 88.2872 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.90584 LAYER Via5 ;
  END store_addr_dmem[10]
  PIN store_addr_dmem[9] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.0962 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.9014 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 17.2964 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 97.765 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.84915 LAYER Via3 ;
  END store_addr_dmem[9]
  PIN store_addr_dmem[8] 
    ANTENNAPARTIALMETALAREA 1.0034 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4838 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.728 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.3048 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 19.8 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 109.089 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.86952 LAYER Via4 ;
  END store_addr_dmem[8]
  PIN store_addr_dmem[7] 
    ANTENNAPARTIALMETALAREA 0.0754 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3078 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.7416 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.366 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 4.7766 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 21.492 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 20.6704 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 113.061 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.87949 LAYER Via5 ;
  END store_addr_dmem[7]
  PIN store_addr_dmem[6] 
    ANTENNAPARTIALMETALAREA 0.0434 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1638 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1776 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.828 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 5.0612 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 22.7412 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 21.5426 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 116.849 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.90328 LAYER Via5 ;
  END store_addr_dmem[6]
  PIN store_addr_dmem[5] 
    ANTENNAPARTIALMETALAREA 0.0434 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1638 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.3752 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7172 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 3.8228 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 17.1684 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 20.6463 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 112.816 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.90499 LAYER Via5 ;
  END store_addr_dmem[5]
  PIN store_addr_dmem[4] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9866 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4082 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.4258 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 75.847 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.84915 LAYER Via3 ;
  END store_addr_dmem[4]
  PIN store_addr_dmem[3] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.5286 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.813 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.2426 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 70.4256 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.85 LAYER Via3 ;
  END store_addr_dmem[3]
  PIN store_addr_dmem[2] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.9286 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.613 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.8509 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 77.7325 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.84687 LAYER Via3 ;
  END store_addr_dmem[2]
  PIN store_addr_dmem[1] 
    ANTENNAPARTIALMETALAREA 0.8914 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9798 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.4384 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.0304 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2079 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 47.2201 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 216.566 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 5.07197 LAYER Via4 ;
    ANTENNADIFFAREA 3.1578 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 8.3778 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 37.6344 LAYER Metal5 ;
    ANTENNAGATEAREA 0.70335 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 124.722 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 565.754 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.30009 LAYER Via5 ;
  END store_addr_dmem[1]
  PIN store_addr_dmem[0] 
    ANTENNAPARTIALMETALAREA 3.9088 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.487 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1332 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 291.629 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 1316.36 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via3 ;
    ANTENNAMAXCUTCAR 4.90023 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2336 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1088 LAYER Metal4 ;
    ANTENNAGATEAREA 0.1332 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 293.383 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1324.68 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0196 LAYER Via4 ;
    ANTENNAMAXCUTCAR 5.04738 LAYER Via4 ;
    ANTENNADIFFAREA 3.1578 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.9112 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 44.532 LAYER Metal5 ;
    ANTENNAGATEAREA 0.62865 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 309.149 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1395.52 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.30909 LAYER Via5 ;
  END store_addr_dmem[0]
  PIN store_we_dmem[3] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.1954 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.3478 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.3717 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 80.1034 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.84915 LAYER Via3 ;
  END store_we_dmem[3]
  PIN store_we_dmem[2] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.0354 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6278 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.6996 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 72.5795 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.85 LAYER Via3 ;
  END store_we_dmem[2]
  PIN store_we_dmem[1] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.0674 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.7718 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.4251 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 75.9248 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.8416 LAYER Via3 ;
  END store_we_dmem[1]
  PIN store_we_dmem[0] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.2586 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6322 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.587 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 72.1547 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.84231 LAYER Via3 ;
  END store_we_dmem[0]
  PIN d_store_dmem_m[31] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.5458 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.9246 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.1497 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 79.0726 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.84487 LAYER Via3 ;
  END d_store_dmem_m[31]
  PIN d_store_dmem_m[30] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.593 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.137 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.6811 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 77.0658 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.84687 LAYER Via3 ;
  END d_store_dmem_m[30]
  PIN d_store_dmem_m[29] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.4486 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.453 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.0235 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 69.4385 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.84744 LAYER Via3 ;
  END d_store_dmem_m[29]
  PIN d_store_dmem_m[28] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.1618 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1966 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.1373 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 70.1299 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.8416 LAYER Via3 ;
  END d_store_dmem_m[28]
  PIN d_store_dmem_m[27] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.0004 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5018 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 9.73704 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 63.794 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.82365 LAYER Via3 ;
  END d_store_dmem_m[27]
  PIN d_store_dmem_m[26] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.0186 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5522 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 9.75513 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 63.8282 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.84744 LAYER Via3 ;
  END d_store_dmem_m[26]
  PIN d_store_dmem_m[25] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.0666 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.7682 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 9.91467 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 64.5829 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.83832 LAYER Via3 ;
  END d_store_dmem_m[25]
  PIN d_store_dmem_m[24] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.0034 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4838 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 9.7463 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 63.7897 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.85 LAYER Via3 ;
  END d_store_dmem_m[24]
  PIN d_store_dmem_m[23] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.2276 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.0242 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.2333 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 79.5274 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.82365 LAYER Via3 ;
  END d_store_dmem_m[23]
  PIN d_store_dmem_m[22] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.2002 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.8694 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.187 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 79.3547 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.84231 LAYER Via3 ;
  END d_store_dmem_m[22]
  PIN d_store_dmem_m[21] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.4002 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2694 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 10.8566 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 68.8179 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.83433 LAYER Via3 ;
  END d_store_dmem_m[21]
  PIN d_store_dmem_m[20] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.702 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.659 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.754 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 72.8231 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.84744 LAYER Via3 ;
  END d_store_dmem_m[20]
  PIN d_store_dmem_m[19] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.7506 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.8462 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.9534 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 73.7897 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.8463 LAYER Via3 ;
  END d_store_dmem_m[19]
  PIN d_store_dmem_m[18] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.7668 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.9506 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.1568 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 74.6368 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.84915 LAYER Via3 ;
  END d_store_dmem_m[18]
  PIN d_store_dmem_m[17] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.9906 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.9262 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.5563 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 76.4333 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.84744 LAYER Via3 ;
  END d_store_dmem_m[17]
  PIN d_store_dmem_m[16] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.8936 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.487 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.3272 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 75.3051 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.84744 LAYER Via3 ;
  END d_store_dmem_m[16]
  PIN d_store_dmem_m[15] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.8182 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.1162 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.8318 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 77.6701 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.83689 LAYER Via3 ;
  END d_store_dmem_m[15]
  PIN d_store_dmem_m[14] 
    ANTENNAPARTIALMETALAREA 1.1298 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0526 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.1832 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.8532 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.8229 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 91.2077 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87536 LAYER Via4 ;
  END d_store_dmem_m[14]
  PIN d_store_dmem_m[13] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.5904 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.1226 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.4179 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 71.2607 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 6.82365 LAYER Via3 ;
  END d_store_dmem_m[13]
  PIN d_store_dmem_m[12] 
    ANTENNAPARTIALMETALAREA 1.993 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.937 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.0288 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.6584 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.7739 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 91.0564 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87422 LAYER Via4 ;
  END d_store_dmem_m[12]
  PIN d_store_dmem_m[11] 
    ANTENNAPARTIALMETALAREA 1.0034 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4838 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.2624 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.7096 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 18.1768 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 101.919 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.85655 LAYER Via4 ;
  END d_store_dmem_m[11]
  PIN d_store_dmem_m[10] 
    ANTENNAPARTIALMETALAREA 1.0674 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.7718 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.6384 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.9016 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.7027 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 90.6402 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END d_store_dmem_m[10]
  PIN d_store_dmem_m[9] 
    ANTENNAPARTIALMETALAREA 0.8434 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7638 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.7032 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.6932 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 18.701 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 104.23 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END d_store_dmem_m[9]
  PIN d_store_dmem_m[8] 
    ANTENNAPARTIALMETALAREA 0.9234 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1238 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.8536 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.37 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 19.4993 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 107.751 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87536 LAYER Via4 ;
  END d_store_dmem_m[8]
  PIN d_store_dmem_m[7] 
    ANTENNADIFFAREA 2.3684 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.997 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.3866 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 22.4465 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 104.675 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.38272 LAYER Via3 ;
  END d_store_dmem_m[7]
  PIN d_store_dmem_m[6] 
    ANTENNAPARTIALMETALAREA 0.7794 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4758 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.86 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.3988 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 46.0382 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 210.345 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87243 LAYER Via4 ;
  END d_store_dmem_m[6]
  PIN d_store_dmem_m[5] 
    ANTENNAPARTIALMETALAREA 0.7778 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4686 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.1232 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0832 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 1.1508 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1444 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 43.8751 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 201.176 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.89508 LAYER Via5 ;
  END d_store_dmem_m[5]
  PIN d_store_dmem_m[4] 
    ANTENNAPARTIALMETALAREA 1.9418 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.6382 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 135.395 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 609.5 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 3.87037 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.1908 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.3532 LAYER Metal4 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 138.501 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 623.462 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.51235 LAYER Via4 ;
  END d_store_dmem_m[4]
  PIN d_store_dmem_m[3] 
    ANTENNAPARTIALMETALAREA 1.8802 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.4294 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.3576 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.638 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 27.2673 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 131.649 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87298 LAYER Via4 ;
  END d_store_dmem_m[3]
  PIN d_store_dmem_m[2] 
    ANTENNAPARTIALMETALAREA 0.2194 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9558 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.4976 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.768 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 2.2056 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 9.8568 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 34.7219 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 158.491 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 6.92816 LAYER Via5 ;
  END d_store_dmem_m[2]
  PIN d_store_dmem_m[1] 
    ANTENNAPARTIALMETALAREA 0.1074 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4518 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 7.4762 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 33.669 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 126.518 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 570.169 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.64815 LAYER Via4 ;
  END d_store_dmem_m[1]
  PIN d_store_dmem_m[0] 
    ANTENNAPARTIALMETALAREA 0.1222 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4842 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.8992 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.5752 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.3834 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 108.204 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 491.826 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.46383 LAYER Via4 ;
  END d_store_dmem_m[0]
  PIN d_load_dmem[31] 
    ANTENNAPARTIALMETALAREA 0.9714 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3398 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.9496 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.802 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 78.2568 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 360.43 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.09415 LAYER Via4 ;
  END d_load_dmem[31]
  PIN d_load_dmem[30] 
    ANTENNAPARTIALMETALAREA 2.009 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.9406 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.04545 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 51.653 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 239.009 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 3.96296 LAYER Via3 ;
  END d_load_dmem[30]
  PIN d_load_dmem[29] 
    ANTENNAPARTIALMETALAREA 1.9124 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.6058 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.183 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.8208 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.04545 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 106.884 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 487.79 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 3.78927 LAYER Via4 ;
  END d_load_dmem[29]
  PIN d_load_dmem[28] 
    ANTENNAPARTIALMETALAREA 1.897 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.505 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.5158 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.3472 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.04545 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 123.672 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 563.757 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.5679 LAYER Via4 ;
  END d_load_dmem[28]
  PIN d_load_dmem[27] 
    ANTENNAPARTIALMETALAREA 1.0354 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6278 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.767 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.4776 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.04545 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 144.036 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 650.072 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.5679 LAYER Via4 ;
  END d_load_dmem[27]
  PIN d_load_dmem[26] 
    ANTENNAPARTIALMETALAREA 1.3084 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.7906 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 47.6573 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 213.641 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 2.5359 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.075 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8348 LAYER Metal4 ;
    ANTENNAGATEAREA 0.04545 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 73.3622 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 338.673 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.5679 LAYER Via4 ;
  END d_load_dmem[26]
  PIN d_load_dmem[25] 
    ANTENNAPARTIALMETALAREA 2.547 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.4246 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 89.7291 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 405.026 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 2.5359 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2292 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9972 LAYER Metal4 ;
    ANTENNAGATEAREA 0.04545 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 94.772 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 426.966 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.5679 LAYER Via4 ;
  END d_load_dmem[25]
  PIN d_load_dmem[24] 
    ANTENNAPARTIALMETALAREA 1.4 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2658 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 201.657 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 908.164 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 2.63504 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.748 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3948 LAYER Metal4 ;
    ANTENNAGATEAREA 0.04545 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 218.115 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 982.857 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.5679 LAYER Via4 ;
  END d_load_dmem[24]
  PIN d_load_dmem[23] 
    ANTENNAPARTIALMETALAREA 0.0586 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.261 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0382 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1692 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 1.2558 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6484 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 34.5903 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 161.739 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 4.69909 LAYER Via5 ;
  END d_load_dmem[23]
  PIN d_load_dmem[22] 
    ANTENNAPARTIALMETALAREA 0.8914 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9798 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.4592 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.624 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.10395 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 110.055 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 500.513 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.17284 LAYER Via4 ;
  END d_load_dmem[22]
  PIN d_load_dmem[21] 
    ANTENNAPARTIALMETALAREA 0.9394 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1958 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.8944 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0536 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 103.232 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 471.646 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.09415 LAYER Via4 ;
  END d_load_dmem[21]
  PIN d_load_dmem[20] 
    ANTENNAPARTIALMETALAREA 1.817 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.1108 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 67.9359 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 305.395 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 3.34786 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.8108 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.6432 LAYER Metal4 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 105.564 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 474.648 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.5679 LAYER Via4 ;
  END d_load_dmem[20]
  PIN d_load_dmem[19] 
    ANTENNAPARTIALMETALAREA 1.0186 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5522 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.6678 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.5312 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 117.984 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 531.937 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.5679 LAYER Via4 ;
  END d_load_dmem[19]
  PIN d_load_dmem[18] 
    ANTENNAPARTIALMETALAREA 1.7982 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.9578 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 40.3458 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 183.556 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.65983 LAYER Via3 ;
  END d_load_dmem[18]
  PIN d_load_dmem[17] 
    ANTENNAPARTIALMETALAREA 1.0674 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.7718 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.765 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 30.4056 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.10395 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 78.3828 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 355.271 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.5679 LAYER Via4 ;
  END d_load_dmem[17]
  PIN d_load_dmem[16] 
    ANTENNAPARTIALMETALAREA 1.2114 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.4198 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 7.0496 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.752 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.10395 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 82.3049 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 377.306 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.5679 LAYER Via4 ;
  END d_load_dmem[16]
  PIN d_load_dmem[15] 
    ANTENNAPARTIALMETALAREA 0.0754 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3078 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 7.8566 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 35.352 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 1.0824 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8996 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 25.2852 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 117.251 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 3.04815 LAYER Via5 ;
  END d_load_dmem[15]
  PIN d_load_dmem[14] 
    ANTENNAPARTIALMETALAREA 0.8274 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6918 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.8036 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 30.6108 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 129.836 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 587.744 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.51624 LAYER Via4 ;
  END d_load_dmem[14]
  PIN d_load_dmem[13] 
    ANTENNAPARTIALMETALAREA 1.9964 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.8866 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 43.5171 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 197.497 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 2.02735 LAYER Via3 ;
  END d_load_dmem[13]
  PIN d_load_dmem[12] 
    ANTENNAPARTIALMETALAREA 2.2058 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.855 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 40.9436 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 184.779 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 2.02735 LAYER Via3 ;
  END d_load_dmem[12]
  PIN d_load_dmem[11] 
    ANTENNAPARTIALMETALAREA 0.7938 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5406 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.9816 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.4748 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 159.992 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 721.21 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.87094 LAYER Via4 ;
  END d_load_dmem[11]
  PIN d_load_dmem[10] 
    ANTENNAPARTIALMETALAREA 1.1466 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1282 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 7.5928 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.1964 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 143.768 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 650.923 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.58632 LAYER Via4 ;
  END d_load_dmem[10]
  PIN d_load_dmem[9] 
    ANTENNAPARTIALMETALAREA 1.7558 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.8642 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 58.359 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 265.005 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 7.10085 LAYER Via3 ;
  END d_load_dmem[9]
  PIN d_load_dmem[8] 
    ANTENNAPARTIALMETALAREA 0.1394 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5958 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 8.2144 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.9936 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 170.451 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 769.159 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 3.64786 LAYER Via4 ;
  END d_load_dmem[8]
  PIN d_load_dmem[7] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 10.2306 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 46.0008 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.04545 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 247.47 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1120.89 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.17858 LAYER Via4 ;
  END d_load_dmem[7]
  PIN d_load_dmem[6] 
    ANTENNAPARTIALMETALAREA 1.8034 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.0838 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 148.257 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 671.097 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 1.92222 LAYER Via3 ;
  END d_load_dmem[6]
  PIN d_load_dmem[5] 
    ANTENNAPARTIALMETALAREA 1.6254 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.2486 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 57.4632 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 260.174 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 1.45299 LAYER Via3 ;
  END d_load_dmem[5]
  PIN d_load_dmem[4] 
    ANTENNAPARTIALMETALAREA 1.2434 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5638 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 7.4312 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 33.4692 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 273.344 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1232.69 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.36239 LAYER Via4 ;
  END d_load_dmem[4]
  PIN d_load_dmem[3] 
    ANTENNAPARTIALMETALAREA 1.1794 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2758 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 7.1656 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 32.274 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 273.392 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1232 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.6094 LAYER Via4 ;
  END d_load_dmem[3]
  PIN d_load_dmem[2] 
    ANTENNAPARTIALMETALAREA 1.0674 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.7718 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 375.047 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 1688.55 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 2.27436 LAYER Via3 ;
  END d_load_dmem[2]
  PIN d_load_dmem[1] 
    ANTENNAPARTIALMETALAREA 1.3074 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.8518 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 8.4776 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 38.178 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 150.978 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 684.841 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.3453 LAYER Via4 ;
  END d_load_dmem[1]
  PIN d_load_dmem[0] 
    ANTENNAPARTIALMETALAREA 1.3074 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.8518 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 167.562 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 759.026 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 2.17778 LAYER Via3 ;
  END d_load_dmem[0]
  PIN trace_pc[31] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8592 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8664 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.6611 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 90.3974 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87536 LAYER Via4 ;
  END trace_pc[31]
  PIN trace_pc[30] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.6768 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.0456 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.8132 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 91.0829 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87707 LAYER Via4 ;
  END trace_pc[30]
  PIN trace_pc[29] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.224 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.508 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.162 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 74.6521 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87707 LAYER Via4 ;
  END trace_pc[29]
  PIN trace_pc[28] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8136 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6612 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.8124 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 77.5795 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[28]
  PIN trace_pc[27] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.008 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.036 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.9631 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 69.2573 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87707 LAYER Via4 ;
  END trace_pc[27]
  PIN trace_pc[26] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.844 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.798 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.4355 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 71.3821 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87536 LAYER Via4 ;
  END trace_pc[26]
  PIN trace_pc[25] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8136 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6612 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.0164 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 69.4974 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[25]
  PIN trace_pc[24] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7832 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5244 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.793 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 68.4923 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[24]
  PIN trace_pc[23] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8136 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6612 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.5697 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 67.4872 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[23]
  PIN trace_pc[22] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.008 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.036 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.205 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 65.8462 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[22]
  PIN trace_pc[21] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8136 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6612 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.79473 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 64 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[21]
  PIN trace_pc[20] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7376 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3192 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.0181 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 65.0051 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[20]
  PIN trace_pc[19] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7072 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.1824 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.0181 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 65.0051 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[19]
  PIN trace_pc[18] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7984 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5928 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.74915 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 63.7949 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[18]
  PIN trace_pc[17] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8136 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6612 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.74915 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 63.7949 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[17]
  PIN trace_pc[16] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8136 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6612 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.4283 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 66.8513 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[16]
  PIN trace_pc[15] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7984 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5928 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.6107 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 67.6718 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[15]
  PIN trace_pc[14] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.6312 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8404 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.1121 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 69.9282 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[14]
  PIN trace_pc[13] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.692 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.114 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.752 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 68.3077 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[13]
  PIN trace_pc[12] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.6312 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8404 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.6107 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 67.6718 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[12]
  PIN trace_pc[11] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.692 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.114 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.1594 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 65.641 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[11]
  PIN trace_pc[10] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.008 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.036 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.3417 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 66.4615 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[10]
  PIN trace_pc[9] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7832 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5244 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.246 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 66.0308 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[9]
  PIN trace_pc[8] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7376 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3192 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.91239 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 64.5991 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END trace_pc[8]
  PIN trace_pc[7] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7984 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5928 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.5933 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 63.1632 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END trace_pc[7]
  PIN trace_pc[6] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7984 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5928 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.0036 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 65.0094 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END trace_pc[6]
  PIN trace_pc[5] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7072 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.1824 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.3226 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 66.4453 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END trace_pc[5]
  PIN trace_pc[4] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.768 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.456 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.2588 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 66.206 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.85655 LAYER Via4 ;
  END trace_pc[4]
  PIN trace_pc[3] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7832 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5244 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.86681 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 64.394 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END trace_pc[3]
  PIN trace_pc[2] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.768 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.456 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.63889 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 63.3684 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END trace_pc[2]
  PIN trace_pc[1] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.388 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.746 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.41097 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 62.3427 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END trace_pc[1]
  PIN trace_pc[0] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8296 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7332 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.33262 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 62.0103 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_pc[0]
  PIN trace_inst[31] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7984 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5928 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.50214 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 62.753 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END trace_inst[31]
  PIN trace_inst[30] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7984 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5928 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.56681 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 62.9744 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_inst[30]
  PIN trace_inst[29] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7984 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5928 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.0682 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 65.2308 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_inst[29]
  PIN trace_inst[28] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7376 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3192 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.8386 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 68.6974 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_inst[28]
  PIN trace_inst[27] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7984 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5928 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.505 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 67.2658 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END trace_inst[27]
  PIN trace_inst[26] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7072 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.1824 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.052 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 69.7274 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END trace_inst[26]
  PIN trace_inst[25] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7376 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3192 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.8241 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 68.7017 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END trace_inst[25]
  PIN trace_inst[24] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8096 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6432 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.5779 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 67.6419 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.85655 LAYER Via4 ;
  END trace_inst[24]
  PIN trace_inst[23] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.6768 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.0456 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.5933 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 63.1632 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END trace_inst[23]
  PIN trace_inst[22] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7832 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5244 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.68447 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 63.5735 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END trace_inst[22]
  PIN trace_inst[21] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7832 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5244 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.5933 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 63.1632 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END trace_inst[21]
  PIN trace_inst[20] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.847 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.78 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.53006 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 62.8077 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87536 LAYER Via4 ;
  END trace_inst[20]
  PIN trace_inst[19] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7832 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5244 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.36538 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 62.1376 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END trace_inst[19]
  PIN trace_inst[18] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7944 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5748 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.36538 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 62.1376 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END trace_inst[18]
  PIN trace_inst[17] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.008 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.036 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.1138 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 65.4359 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_inst[17]
  PIN trace_inst[16] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8136 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6612 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.0682 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 65.2308 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_inst[16]
  PIN trace_inst[15] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8136 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6612 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.93148 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 64.6154 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_inst[15]
  PIN trace_inst[14] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.2552 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6484 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.611 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 72.1718 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87536 LAYER Via4 ;
  END trace_inst[14]
  PIN trace_inst[13] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7984 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5928 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.68447 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 63.5735 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87479 LAYER Via4 ;
  END trace_inst[13]
  PIN trace_inst[12] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.4488 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0196 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.6588 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 76.888 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87707 LAYER Via4 ;
  END trace_inst[12]
  PIN trace_inst[11] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0192 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.1278 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 74.6162 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.85655 LAYER Via4 ;
  END trace_inst[11]
  PIN trace_inst[10] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.0984 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.9428 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.2434 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 66.0547 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.86624 LAYER Via4 ;
  END trace_inst[10]
  PIN trace_inst[9] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.996 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.482 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.8677 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 73.3325 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.86083 LAYER Via4 ;
  END trace_inst[9]
  PIN trace_inst[8] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.84 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.78 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.9871 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 84.444 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.40197 LAYER Via4 ;
  END trace_inst[8]
  PIN trace_inst[7] 
    ANTENNADIFFAREA 1.65 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.8096 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6432 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2331 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.2475 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 85.6203 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.38095 LAYER Via4 ;
  END trace_inst[7]
  PIN trace_inst[6] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.9616 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3272 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.91011 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 64.5188 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87707 LAYER Via4 ;
  END trace_inst[6]
  PIN trace_inst[5] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0192 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.0469 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 65.1342 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87707 LAYER Via4 ;
  END trace_inst[5]
  PIN trace_inst[4] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0192 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.138 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 65.5444 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87707 LAYER Via4 ;
  END trace_inst[4]
  PIN trace_inst[3] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.2352 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5584 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.9175 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 69.0521 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87707 LAYER Via4 ;
  END trace_inst[3]
  PIN trace_inst[2] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.5088 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.7896 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.6999 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 77.0726 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87707 LAYER Via4 ;
  END trace_inst[2]
  PIN trace_inst[1] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0192 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.1845 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 83.7538 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.87792 LAYER Via4 ;
  END trace_inst[1]
  PIN trace_inst[0] 
    ANTENNADIFFAREA 2.3684 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.2436 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.125 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.351 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 17.0161 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 96.6137 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.86624 LAYER Via4 ;
  END trace_inst[0]
END datapath

END LIBRARY
